## firmware/esp32/sdkconfig.defaults
```kconfig
CONFIG_SPIRAM=y
CONFIG_SPIRAM_MODE_OCTAL=y
CONFIG_SPIRAM_S3_BOOTLOADER_ENABLE=y
CONFIG_SPIRAM_MALLOC_RESERVE_INTERNAL_MEM=16384
```
